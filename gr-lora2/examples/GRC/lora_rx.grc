<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_rx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>LoRa RX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>CR</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2**SF</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2304000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_samp_rate</value></param>
<param><key>value</key><value>int(8e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SF</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>T</value></param>
<param><key>value</key><value>float(M)/chan_bw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>attenuation</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label</key><value>Attenuation</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.25</value></param>
<param><key>stop</key><value>89.75</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_bw</value></param>
<param><key>value</key><value>125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_freq</value></param>
<param><key>value</key><value>868e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_margin</value></param>
<param><key>value</key><value>75000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>6*chan_bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_syms</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>chan_bw</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0/numpy.pi</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/amarquet/Documents/postdoc-imt/projets-S5/2018/sdr/emetteur-recepteur-lora-sdr/scripts/zeros_2.raw</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/amarquet/Documents/postdoc-imt/projets-S5/2018/sdr/emetteur-recepteur-lora-sdr/scripts/zeros.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len_bits</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>M</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0</value></param>
<param><key>interp</key><value>M</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Preamble detect</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len_bits</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>M</value></param>
</block>
<block>
<key>digital_header_payload_demux</key>
<param><key>id</key><value>digital_header_payload_demux_0</value></param>
<param><key>header_len</key><value>8</value></param>
<param><key>header_padding</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>items_per_symbol</key><value>1</value></param>
<param><key>length_tag_key</key><value>"packet_len_syms"</value></param>
<param><key>output_symbols</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>special_tags</key><value>()</value></param>
<param><key>timing_tag_key</key><value></value></param>
<param><key>trigger_tag_key</key><value>"pkt_start"</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-freq_offset</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>RF_samp_rate</value></param>
<param><key>taps</key><value>1</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>lora2_css_demod</key>
<param><key>id</key><value>lora2_css_demod_0</value></param>
<param><key>freq_loop_gain</key><value>0.1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>time_loop_gain</key><value>0.05</value></param>
</block>
<block>
<key>lora2_css_sync_and_vectorize</key>
<param><key>id</key><value>lora2_css_sync_and_vectorize_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>lora2_flip_half_bytes</key>
<param><key>id</key><value>lora2_flip_half_bytes_0</value></param>
<param><key>_enabled</key><value>2</value></param>
</block>
<block>
<key>lora2_freq_xlating</key>
<param><key>id</key><value>lora2_freq_xlating_0</value></param>
<param><key>freq</key><value>0.0</value></param>
</block>
<block>
<key>lora2_gray_encode</key>
<param><key>id</key><value>lora2_gray_encode_0</value></param>
</block>
<block>
<key>lora2_gray_encode</key>
<param><key>id</key><value>lora2_gray_encode_0_0</value></param>
</block>
<block>
<key>lora2_lora_deinterleaver</key>
<param><key>id</key><value>lora2_lora_deinterleaver_0</value></param>
<param><key>CR</key><value>4</value></param>
<param><key>reduced_rate</key><value>True</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<block>
<key>lora2_lora_deinterleaver</key>
<param><key>id</key><value>lora2_lora_deinterleaver_0_0</value></param>
<param><key>CR</key><value>CR</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<block>
<key>lora2_lora_depad</key>
<param><key>id</key><value>lora2_lora_depad_0</value></param>
<param><key>len_tag_key</key><value>packet_len_bits</value></param>
<param><key>n_pad</key><value>0</value></param>
</block>
<block>
<key>lora2_lora_detect_sof</key>
<param><key>id</key><value>lora2_lora_detect_sof_0</value></param>
<param><key>SF</key><value>9</value></param>
</block>
<block>
<key>lora2_lora_hamming_decode</key>
<param><key>id</key><value>lora2_lora_hamming_decode_0</value></param>
<param><key>CR</key><value>4</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>lora2_lora_hamming_decode</key>
<param><key>id</key><value>lora2_lora_hamming_decode_0_0</value></param>
<param><key>CR</key><value>CR</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>len_tag_key</key><value>packet_len_bits</value></param>
</block>
<block>
<key>lora2_lora_header_decode</key>
<param><key>id</key><value>lora2_lora_header_decode_0</value></param>
<param><key>check_crc</key><value>True</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<block>
<key>lora2_lora_low_rate_opt_rx</key>
<param><key>id</key><value>lora2_lora_low_rate_opt_rx_0</value></param>
</block>
<block>
<key>lora2_lora_merge_rem</key>
<param><key>id</key><value>lora2_lora_merge_rem_0</value></param>
<param><key>len_tag_key</key><value>packet_len_bits</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<block>
<key>lora2_lora_preamble_detect</key>
<param><key>id</key><value>lora2_lora_preamble_detect_0_0</value></param>
<param><key>preamble_len</key><value>8</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>thres</key><value>1e-4</value></param>
</block>
<block>
<key>lora2_lora_whiten</key>
<param><key>id</key><value>lora2_lora_whiten_0</value></param>
<param><key>CR</key><value>4</value></param>
<param><key>len_tag_key</key><value>packet_len_bits</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0</value></param>
<param><key>bandwidth</key><value>chan_bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>channel_list</key><value>[868e6]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>False</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>chan_bw*interp</value></param>
<param><key>sf</key><value>SF</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>(chan_bw + chan_margin)/2</value></param>
<param><key>decim</key><value>interp</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>chan_bw*interp</value></param>
<param><key>width</key><value>(chan_bw + chan_margin)/8</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bb_gain0</key><value>0.0</value></param>
<param><key>corr0</key><value>10</value></param>
<param><key>freq0</key><value>int(chan_freq + freq_offset)</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0.0</value></param>
<param><key>gain0</key><value>0.0</value></param>
<param><key>args</key><value>hackrf=2db1e1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>RF_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0xFFFFF</value></param>
<param><key>uri</key><value>ip:192.168.2.1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>int(chan_freq + freq_offset)</value></param>
<param><key>manual_gain</key><value>attenuation</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>int(chan_bw + chan_margin)</value></param>
<param><key>samplerate</key><value>RF_samp_rate</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>RF_samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>8</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>"Freq"</value></param>
<param><key>marker2</key><value>8</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>"Time"</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>8*(n_syms+8+2+2)*M</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>M</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"CFO est"</value></param>
<param><key>marker1</key><value>8</value></param>
<param><key>size</key><value>8*(n_syms+8+2+2)</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.0/M</value></param>
<param><key>ymin</key><value>-1.0/M</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Time est"</value></param>
<param><key>marker1</key><value>8</value></param>
<param><key>size</key><value>8*(n_syms+8+2+2)</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.0</value></param>
<param><key>ymin</key><value>0.0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Frequency of modulated signal"</value></param>
<param><key>size</key><value>100*M</value></param>
<param><key>srate</key><value>chan_bw</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>8</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>M</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(RF_samp_rate)</value></param>
<param><key>interp</key><value>chan_bw*interp</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>filtered_sig</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>to_hdr_demod</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>hdr_data</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>demod_syms</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>to_payload_demod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>filtered_sig</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>to_hdr_demod</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>hdr_data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>demod_syms</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>to_payload_demod</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>lora2_flip_half_bytes_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>blocks_repeat_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_sync_and_vectorize_0</source_block_id><sink_block_id>lora2_css_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_flip_half_bytes_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_freq_xlating_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_freq_xlating_0</source_block_id><sink_block_id>lora2_css_sync_and_vectorize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_gray_encode_0</source_block_id><sink_block_id>lora2_lora_deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_gray_encode_0_0</source_block_id><sink_block_id>lora2_lora_deinterleaver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_deinterleaver_0</source_block_id><sink_block_id>lora2_lora_hamming_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_deinterleaver_0_0</source_block_id><sink_block_id>lora2_lora_depad_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_depad_0</source_block_id><sink_block_id>lora2_lora_merge_rem_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_detect_sof_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_detect_sof_0</source_block_id><sink_block_id>lora2_freq_xlating_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_hamming_decode_0</source_block_id><sink_block_id>lora2_lora_header_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_hamming_decode_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_header_decode_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>hdr</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora2_lora_low_rate_opt_rx_0</source_block_id><sink_block_id>lora2_gray_encode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_merge_rem_0</source_block_id><sink_block_id>lora2_lora_whiten_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_preamble_detect_0_0</source_block_id><sink_block_id>lora2_lora_detect_sof_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_whiten_0</source_block_id><sink_block_id>lora2_lora_hamming_decode_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>frames</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>lora_lora_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>lora2_lora_preamble_detect_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>lora2_lora_low_rate_opt_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>out</source_key><sink_key>header_data</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>lora2_gray_encode_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
