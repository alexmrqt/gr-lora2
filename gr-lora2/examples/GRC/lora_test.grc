options:
  parameters:
    generate_options: qt_gui
    id: lora_test
    output_language: python
    title: LoRa Test
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2**SF
  states: {}
- name: RF_samp_rate
  id: variable
  parameters:
    value: '2304000'
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: T
  id: variable
  parameters:
    value: float(M)/chan_bw
  states: {}
- name: chan_bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: chan_margin
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.001'
    stop: '1.5'
    value: '1.0'
  states: {state: disabled}
- name: f_delta
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-1.0'
    step: 1.0/(4*M)
    stop: '1.0'
    value: '0'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '8'
  states: {}
- name: n_bytes
  id: variable
  parameters:
    value: '100'
  states: {}
- name: n_syms
  id: variable
  parameters:
    value: int(numpy.ceil((n_bytes*8.0)/SF))
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.4'
  states: {}
- name: sig_amp
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: 2*numpy.pi
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: M-1
    type: short
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1.0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: M-1
    min: '0'
    num_samps: n_syms
    repeat: 'True'
    type: short
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 0.0/(M*interp)
    offset: '0'
    phase: '0'
    samp_rate: interp
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: M
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '3'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: n_syms
    type: short
  states: {state: bypassed}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: chan_bw*interp
    type: complex
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: short
    vector: numpy.arange(0, n_syms, dtype=numpy.int16).tolist()
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: short
    vector: (0, M/2)
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: M
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: lora2_css_demod_0
  id: lora2_css_demod
  parameters:
    B_cfo: '0.35'
    B_delay: '0.4'
    M: M
    interp: interp
  states: {}
- name: lora2_css_fine_delay_detector_0
  id: lora2_css_fine_delay_detector
  parameters:
    M: M
    Q: interp
  states: {state: disabled}
- name: lora2_css_mod_0
  id: lora2_css_mod
  parameters:
    M: M
    interp: interp
  states: {}
- name: lora2_lora_add_preamble_0
  id: lora2_lora_add_preamble
  parameters:
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload"'
    pre_len: '8'
    sync_word: '0x12'
    sync_word_tag_key: '"sync_word"'
  states: {state: bypassed}
- name: lora2_lora_add_reversed_chirps_0
  id: lora2_lora_add_reversed_chirps
  parameters:
    SF: SF
    interp: interp
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload"'
    rev_chirps_tag_key: '"rev_chirps"'
  states: {state: bypassed}
- name: mmse_interpolator_xx_0
  id: mmse_interpolator_xx
  parameters:
    interp_ratio: '1.0'
    phase_shift: '0.1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: n_syms
    srate: '1.0'
    type: float
    ymax: interp
    ymin: '-interp'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    marker1: '8'
    name: '"Spectrum"'
    size: n_syms*M
    srate: '1.0'
    stemplot: 'True'
    tr_tag: '"pkt_start"'
    type: float
    ymax: M
    ymin: '-M'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"CFO err"'
    size: n_syms
    srate: '1.0'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Delay err"'
    size: n_syms
    srate: '1.0'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mod_sig
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: recvd_sig
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: syms
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mod_sig
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: recvd_sig
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: syms
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_0, '0', mmse_interpolator_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0, '0', virtual_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', blocks_delay_0, '0']
- [blocks_multiply_xx_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', blocks_add_xx_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_0, '0']
- [lora2_css_demod_0, '0', blocks_null_sink_1, '0']
- [lora2_css_demod_0, '1', blocks_vector_to_stream_0, '0']
- [lora2_css_demod_0, '2', blocks_multiply_const_vxx_0, '0']
- [lora2_css_demod_0, '3', qtgui_time_sink_x_1_0, '0']
- [lora2_css_fine_delay_detector_0, '0', qtgui_time_sink_x_0, '0']
- [lora2_css_mod_0, '0', lora2_lora_add_reversed_chirps_0, '0']
- [lora2_lora_add_preamble_0, '0', lora2_css_mod_0, '0']
- [lora2_lora_add_reversed_chirps_0, '0', virtual_sink_0, '0']
- [mmse_interpolator_xx_0, '0', blocks_delay_0_0, '0']
- [virtual_source_1, '0', blocks_throttle_0, '0']
- [virtual_source_1_0, '0', lora2_css_demod_0, '0']
- [virtual_source_1_0, '0', lora2_css_fine_delay_detector_0, '0']
- [virtual_source_2, '0', lora2_lora_add_preamble_0, '0']

metadata:
  file_format: 1
