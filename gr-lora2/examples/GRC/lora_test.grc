<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>LoRa Test</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2**SF</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>RF_samp_rate</value></param>
<param><key>value</key><value>2304000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SF</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>T</value></param>
<param><key>value</key><value>float(M)/chan_bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_bw</value></param>
<param><key>value</key><value>125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_margin</value></param>
<param><key>value</key><value>75000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>epsilon</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>1.5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>f_delta</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1.0</value></param>
<param><key>step</key><value>1.0/(4*M)</value></param>
<param><key>stop</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_bytes</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_syms</value></param>
<param><key>value</key><value>int(numpy.ceil((n_bytes*8.0)/SF))</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>value</key><value>0.4</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sig_amp</value></param>
<param><key>value</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>theta</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>2*numpy.pi</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0/numpy.pi</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>M-1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>n_syms</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>n_syms</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>chan_bw*interp</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>numpy.linspace(0, M-1, M, dtype=numpy.int16).tolist()</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(0, M/2)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>M</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>f_delta</value></param>
<param><key>noise_voltage</key><value>noise_amp</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 </value></param>
</block>
<block>
<key>fractional_interpolator_xx</key>
<param><key>id</key><value>fractional_interpolator_xx_0</value></param>
<param><key>interp_ratio</key><value>1.0</value></param>
<param><key>phase_shift</key><value>0.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>lora2_css_demod</key>
<param><key>id</key><value>lora2_css_demod_0</value></param>
<param><key>freq_loop_gain</key><value>0.1</value></param>
<param><key>M</key><value>M</value></param>
<param><key>time_loop_gain</key><value>0.1</value></param>
</block>
<block>
<key>lora2_css_mod</key>
<param><key>id</key><value>lora2_css_mod_0</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>len_tag_key</key><value>'packet_len'</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>lora2_css_sync_and_vectorize</key>
<param><key>id</key><value>lora2_css_sync_and_vectorize_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>lora2_freq_xlating</key>
<param><key>id</key><value>lora2_freq_xlating_0</value></param>
<param><key>freq</key><value>0.0</value></param>
</block>
<block>
<key>lora2_gray_decode</key>
<param><key>id</key><value>lora2_gray_decode_0</value></param>
</block>
<block>
<key>lora2_lora_add_preamble</key>
<param><key>id</key><value>lora2_lora_add_preamble_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>payload_tag_key</key><value>"payload"</value></param>
<param><key>pre_len</key><value>8</value></param>
<param><key>sync_word_tag_key</key><value>"sync_word"</value></param>
<param><key>sync_word</key><value>0x12</value></param>
</block>
<block>
<key>lora2_lora_add_reversed_chirps</key>
<param><key>id</key><value>lora2_lora_add_reversed_chirps_0</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>payload_tag_key</key><value>"payload"</value></param>
<param><key>rev_chirps_tag_key</key><value>"rev_chirps"</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<block>
<key>lora2_lora_detect_sof</key>
<param><key>id</key><value>lora2_lora_detect_sof_0</value></param>
<param><key>SF</key><value>9</value></param>
</block>
<block>
<key>lora2_lora_preamble_detect</key>
<param><key>id</key><value>lora2_lora_preamble_detect_0_0</value></param>
<param><key>preamble_len</key><value>8</value></param>
<param><key>SF</key><value>SF</value></param>
<param><key>thres</key><value>1e-5</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>(chan_bw + chan_margin)/2</value></param>
<param><key>decim</key><value>interp</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>chan_bw*interp</value></param>
<param><key>width</key><value>(chan_bw + chan_margin)/8</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>1</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2*M</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_RECTANGULAR</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>8</value></param>
<param><key>size</key><value>2*(n_syms+8+2+2)*M</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>M</value></param>
<param><key>ymin</key><value>-M</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"CFO est"</value></param>
<param><key>marker1</key><value>8</value></param>
<param><key>name</key><value>"CFO est"</value></param>
<param><key>size</key><value>2*(n_syms+8+2+2)</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.0/M</value></param>
<param><key>ymin</key><value>-1.0/M</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Phase est"</value></param>
<param><key>marker1</key><value>8</value></param>
<param><key>name</key><value>"Time_est"</value></param>
<param><key>size</key><value>2*(n_syms+8+2+2)</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2.0*numpy.pi</value></param>
<param><key>ymin</key><value>-2.0*numpy.pi</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>"Symbols"</value></param>
<param><key>marker1</key><value>8</value></param>
<param><key>size</key><value>2*(n_syms+8+2+2)</value></param>
<param><key>srate</key><value>1.0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>M</value></param>
<param><key>ymin</key><value>-M</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"Frequency of modulated signal"</value></param>
<param><key>size</key><value>(n_syms+8+2+2)*M</value></param>
<param><key>srate</key><value>chan_bw</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>RF_samp_rate</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>chan_bw*interp</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>chan_bw*interp</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>interp</key><value>RF_samp_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>mod_sig</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>recvd_sig</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>syms</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>mod_sig</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>stream_id</key><value>recvd_sig</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>syms</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>channels_channel_model_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>lora2_gray_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_0</source_block_id><sink_block_id>fractional_interpolator_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fractional_interpolator_xx_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_demod_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_mod_0</source_block_id><sink_block_id>lora2_lora_add_reversed_chirps_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_sync_and_vectorize_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_sync_and_vectorize_0</source_block_id><sink_block_id>lora2_css_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_freq_xlating_0</source_block_id><sink_block_id>lora2_css_sync_and_vectorize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_gray_decode_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_add_preamble_0</source_block_id><sink_block_id>lora2_css_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_add_reversed_chirps_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_detect_sof_0</source_block_id><sink_block_id>lora2_freq_xlating_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_preamble_detect_0_0</source_block_id><sink_block_id>lora2_lora_detect_sof_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>lora2_lora_preamble_detect_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>lora2_lora_add_preamble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
