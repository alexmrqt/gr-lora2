options:
  parameters:
    author: Alexandre Marquet, Lies Temzi, Juan Pablo Hagata
    generate_options: qt_gui
    id: lora_interleaver_test
    output_language: python
    title: LoRa Interleaver Test
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '4'
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (205,100,0)
  states: {state: disabled}
- name: lora2_lora_deinterleaver_0
  id: lora2_lora_deinterleaver
  parameters:
    CR: CR
    SF: SF
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_interleaver_0
  id: lora2_lora_interleaver
  parameters:
    CR: CR
    SF: SF
    len_tag_key: ''
    reduced_rate: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: '"Input bits"'
    label2: '"Output bits"'
    marker1: '0'
    marker2: '3'
    nconnections: '2'
    size: '50'
    srate: '1.0'
    stemplot: 'True'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: output_bits
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: input_bits
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: input_bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: output_bits
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_unpack_k_bits_bb_0, '0', lora2_lora_interleaver_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [lora2_lora_deinterleaver_0, '0', virtual_sink_0, '0']
- [lora2_lora_interleaver_0, '0', lora2_lora_deinterleaver_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_0_0, '0']

metadata:
  file_format: 1
