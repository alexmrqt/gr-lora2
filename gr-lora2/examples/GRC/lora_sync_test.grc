<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_sync_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>M</value></param>
<param><key>value</key><value>2**SF</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SF</value></param>
<param><key>value</key><value>9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cfo</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_bw</value></param>
<param><key>value</key><value>125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_margin</value></param>
<param><key>value</key><value>75000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_syms</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_var</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise_var</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>cfo</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>1.0</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>n_syms</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(0, M/2)</value></param>
</block>
<block>
<key>grc_css_demod</key>
<param><key>id</key><value>grc_css_demod_0</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>lora2_css_mod</key>
<param><key>id</key><value>lora2_css_mod_0</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>len_tag_key</key><value>'packet_len'</value></param>
<param><key>M</key><value>M</value></param>
</block>
<block>
<key>lora2_freq_xlating</key>
<param><key>id</key><value>lora2_freq_xlating_0</value></param>
<param><key>freq_tag_key</key><value>'freq_offset'</value></param>
<param><key>freq</key><value>0.0</value></param>
</block>
<block>
<key>lora2_gray_decode</key>
<param><key>id</key><value>lora2_gray_decode_0</value></param>
</block>
<block>
<key>lora2_lora_add_preamble</key>
<param><key>id</key><value>lora2_lora_add_preamble_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>payload_tag_key</key><value>"payload"</value></param>
<param><key>pre_len</key><value>8</value></param>
<param><key>sync_word_tag_key</key><value>"sync_word"</value></param>
<param><key>sync_word</key><value>0x12</value></param>
</block>
<block>
<key>lora2_lora_add_reversed_chirps</key>
<param><key>id</key><value>lora2_lora_add_reversed_chirps_0</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>payload_tag_key</key><value>"payload"</value></param>
<param><key>rev_chirps_tag_key</key><value>"rev_chirps"</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<block>
<key>lora2_lora_implicit_get_payload</key>
<param><key>id</key><value>lora2_lora_implicit_get_payload_0</value></param>
<param><key>CR</key><value>0</value></param>
<param><key>has_crc</key><value>False</value></param>
<param><key>payload_len</key><value>n_syms</value></param>
<param><key>SF</key><value></value></param>
</block>
<block>
<key>lora2_lora_preamble_detect</key>
<param><key>id</key><value>lora2_lora_preamble_detect_0_0</value></param>
<param><key>preamble_len</key><value>8</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>lora2_lora_preamble_detect_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>lora2_gray_decode_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grc_css_demod_0</source_block_id><sink_block_id>lora2_lora_implicit_get_payload_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_css_mod_0</source_block_id><sink_block_id>lora2_lora_add_reversed_chirps_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_freq_xlating_0</source_block_id><sink_block_id>grc_css_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_gray_decode_0</source_block_id><sink_block_id>lora2_lora_add_preamble_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_add_preamble_0</source_block_id><sink_block_id>lora2_css_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_add_reversed_chirps_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lora2_lora_implicit_get_payload_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora2_lora_preamble_detect_0_0</source_block_id><sink_block_id>lora2_freq_xlating_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
