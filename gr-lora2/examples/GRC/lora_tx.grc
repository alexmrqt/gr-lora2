options:
  parameters:
    generate_options: qt_gui
    id: lora_tx
    output_language: python
    title: LoRa TX
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '3'
  states: {}
- name: M
  id: variable
  parameters:
    value: 2**SF
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: hdr_format
  id: lora2_lora_header_format
  parameters:
    SF: SF
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1.0/numpy.pi
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("has_crc")
    v: pmt.PMT_T if has_crc else pmt.PMT_F
  states: {}
- name: blocks_pdu_set_0_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("CR")
    v: pmt.from_long(CR)
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: short
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: lora2_css_mod_0
  id: lora2_css_mod
  parameters:
    M: M
    interp: '2'
  states: {}
- name: lora2_flip_half_bytes_0
  id: lora2_flip_half_bytes
  parameters: {}
  states: {}
- name: lora2_gray_decode_0
  id: lora2_gray_decode
  parameters: {}
  states: {}
- name: lora2_gray_decode_0_0
  id: lora2_gray_decode
  parameters: {}
  states: {}
- name: lora2_lora_add_preamble_0
  id: lora2_lora_add_preamble
  parameters:
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload_start"'
    pre_len: '8'
    sync_word: '0x12'
    sync_word_tag_key: '"sync_word"'
  states: {}
- name: lora2_lora_add_reversed_chirps_0
  id: lora2_lora_add_reversed_chirps
  parameters:
    SF: M
    interp: '2'
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload_start"'
    rev_chirps_tag_key: '"rev_chirp"'
  states: {}
- name: lora2_lora_crc_0
  id: lora2_lora_crc
  parameters:
    check: 'False'
  states: {}
- name: lora2_lora_hamming_encode_0
  id: lora2_lora_hamming_encode
  parameters:
    CR: '4'
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_hamming_encode_0_0
  id: lora2_lora_hamming_encode
  parameters:
    CR: CR
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_interleaver_0
  id: lora2_lora_interleaver
  parameters:
    CR: '4'
    SF: SF
    reduced_rate: 'True'
  states: {}
- name: lora2_lora_interleaver_1
  id: lora2_lora_interleaver
  parameters:
    CR: CR
    SF: SF
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_low_rate_opt_tx_0
  id: lora2_lora_low_rate_opt_tx
  parameters: {}
  states: {}
- name: lora2_lora_pad_0
  id: lora2_lora_pad
  parameters:
    CR: CR
    SF: SF
    len_tag_key: '"packet_len"'
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_whiten_0
  id: lora2_lora_whiten
  parameters:
    len_tag_key: packet_len
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: ''
    size: 20*M
    srate: '1.0'
    tr_delay: 20*M
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"time_offset"'
    type: float
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: header_syms
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: payload_syms
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: payload_syms
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: header_syms
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_pdu_set_0, pdus, blocks_pdu_set_0_0, pdus]
- [blocks_pdu_set_0_0, pdus, lora2_lora_crc_0, pdus]
- [blocks_pdu_to_tagged_stream_0_0_0, '0', lora2_flip_half_bytes_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0_0, '0', lora2_lora_hamming_encode_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0_0_0, '0', lora2_lora_hamming_encode_0_0, '0']
- [blocks_repack_bits_bb_0, '0', lora2_lora_whiten_0, '0']
- [blocks_socket_pdu_0_0, pdus, blocks_pdu_set_0, pdus]
- [blocks_tagged_stream_mux_0, '0', lora2_lora_add_preamble_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, virtual_sink_0_1, '0']
- [digital_protocol_formatter_async_0, payload, virtual_sink_0_1_0, '0']
- [lora2_css_mod_0, '0', lora2_lora_add_reversed_chirps_0, '0']
- [lora2_flip_half_bytes_0, '0', blocks_repack_bits_bb_0, '0']
- [lora2_gray_decode_0, '0', lora2_lora_low_rate_opt_tx_0, '0']
- [lora2_gray_decode_0_0, '0', virtual_sink_1_0, '0']
- [lora2_lora_add_preamble_0, '0', lora2_css_mod_0, '0']
- [lora2_lora_add_reversed_chirps_0, '0', virtual_sink_1_0_0, '0']
- [lora2_lora_crc_0, pdus, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [lora2_lora_hamming_encode_0, '0', lora2_lora_interleaver_0, '0']
- [lora2_lora_hamming_encode_0_0, '0', lora2_lora_pad_0, '0']
- [lora2_lora_interleaver_0, '0', lora2_gray_decode_0, '0']
- [lora2_lora_interleaver_1, '0', lora2_gray_decode_0_0, '0']
- [lora2_lora_low_rate_opt_tx_0, '0', virtual_sink_1, '0']
- [lora2_lora_pad_0, '0', lora2_lora_interleaver_1, '0']
- [lora2_lora_whiten_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [virtual_source_0, '0', blocks_pdu_to_tagged_stream_0_0_0_0, pdus]
- [virtual_source_0_0, '0', blocks_pdu_to_tagged_stream_0_0_0_0_0, pdus]
- [virtual_source_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_0_0_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_0_1, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
