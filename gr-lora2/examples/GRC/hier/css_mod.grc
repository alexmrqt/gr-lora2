options:
  parameters:
    author: Alexandre Marquet
    category: lora2
    generate_options: hb
    id: grc_css_mod
    output_language: python
    title: GRC CSS Modulator
  states: {}

blocks:
- name: base_sym_t
  id: variable
  parameters:
    value: numpy.concatenate(([1], numpy.zeros(M-1)))
  states: {}
- name: chirp
  id: variable
  parameters:
    value: numpy.exp(1j*numpy.pi*k/M*k)
  states: {}
- name: k
  id: variable
  parameters:
    value: numpy.linspace(0, M-1, M)
  states: {}
- name: syms_table
  id: variable
  parameters:
    value: numpy.concatenate([numpy.roll(base_sym_t, shift) for shift in range(0, M)])
  states: {}
- name: M
  id: parameter
  parameters:
    label: M
    value: '128'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: M
    type: complex
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: chirp
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: M
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: M
    in_type: short
    out_type: complex
    symbol_table: syms_table
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: M
    forward: 'False'
    shift: 'True'
    type: complex
    window: numpy.ones(M)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: short
  states: {}

connections:
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_source_x_1, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_xx_0, '1']
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [pad_source_0, '0', digital_chunks_to_symbols_xx_0, '0']

metadata:
  file_format: 1
