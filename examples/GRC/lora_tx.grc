options:
  parameters:
    generate_options: qt_gui
    id: lora_tx
    output_language: python
    title: LoRa TX
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '4'
  states: {}
- name: M
  id: variable
  parameters:
    value: 2**SF
  states: {}
- name: RF_samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '6'
    stop: '62'
    value: '0'
  states: {}
- name: chan_bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: chan_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: chan_margin
  id: variable
  parameters:
    value: chan_bw/(5/3)
  states: {}
- name: frac_interp
  id: variable
  parameters:
    value: RF_samp_rate/((RF_samp_rate//(interp*chan_bw))*(interp*chan_bw))
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: hdr_format
  id: lora2_lora_header_format
  parameters:
    SF: SF
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '2'
  states: {}
- name: interp2
  id: variable
  parameters:
    value: int(RF_samp_rate//(interp*chan_bw))
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '10.7'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: chan_bw
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1.0/numpy.pi
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("has_crc")
    v: pmt.PMT_T if has_crc else pmt.PMT_F
  states: {}
- name: blocks_pdu_set_0_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("CR")
    v: pmt.from_long(CR)
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: short
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: '[1.0]'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: RF_samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: lora2_css_mod_0
  id: lora2_css_mod
  parameters:
    M: M
    interp: interp
  states: {}
- name: lora2_flip_half_bytes_0
  id: lora2_flip_half_bytes
  parameters: {}
  states: {}
- name: lora2_gray_decode_0
  id: lora2_gray_decode
  parameters: {}
  states: {}
- name: lora2_gray_decode_0_0
  id: lora2_gray_decode
  parameters: {}
  states: {}
- name: lora2_lora_add_preamble_0
  id: lora2_lora_add_preamble
  parameters:
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload_start"'
    pre_len: '8'
    sync_word: '0x12'
    sync_word_tag_key: '"sync_word"'
  states: {}
- name: lora2_lora_add_reversed_chirps_0
  id: lora2_lora_add_reversed_chirps
  parameters:
    SF: SF
    interp: interp
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload_start"'
    rev_chirps_tag_key: '"rev_chirp"'
  states: {}
- name: lora2_lora_crc_0
  id: lora2_lora_crc
  parameters:
    check: 'False'
  states: {}
- name: lora2_lora_drop_rem_0
  id: lora2_lora_drop_rem
  parameters:
    SF: SF
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_hamming_encode_0
  id: lora2_lora_hamming_encode
  parameters:
    CR: '4'
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_hamming_encode_0_0
  id: lora2_lora_hamming_encode
  parameters:
    CR: CR
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_interleaver_0
  id: lora2_lora_interleaver
  parameters:
    CR: '4'
    SF: SF
    len_tag_key: packet_len
    reduced_rate: 'True'
  states: {}
- name: lora2_lora_interleaver_1
  id: lora2_lora_interleaver
  parameters:
    CR: CR
    SF: SF
    len_tag_key: packet_len
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_low_rate_opt_tx_0
  id: lora2_lora_low_rate_opt_tx
  parameters: {}
  states: {}
- name: lora2_lora_pad_0
  id: lora2_lora_pad
  parameters:
    CR: CR
    SF: SF
    len_tag_key: '"packet_len"'
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_whiten_0
  id: lora2_lora_whiten
  parameters:
    len_tag_key: packet_len
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: (chan_bw + chan_margin)/2
    gain: interp2*0.9
    interp: interp2
    samp_rate: RF_samp_rate
    type: interp_fir_filter_ccf
    width: (chan_bw + chan_margin)/8
    win: firdes.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0.0'
    resamp_ratio: 1.0/frac_interp
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: bb_gain
    corr0: ppm
    freq0: chan_freq-freq_offset
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: RF_samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: RF_samp_rate
    fc: chan_freq-freq_offset
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: M*100
    srate: '1.0'
    stemplot: 'True'
    type: float
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: header_syms
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: payload_syms
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: payload_syms
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: header_syms
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_pdu_set_0, pdus, blocks_pdu_set_0_0, pdus]
- [blocks_pdu_set_0_0, pdus, lora2_lora_crc_0, pdus]
- [blocks_pdu_to_tagged_stream_0_0_0, '0', lora2_flip_half_bytes_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0_0, '0', lora2_lora_hamming_encode_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0_0_0, '0', lora2_lora_drop_rem_0, '0']
- [blocks_repack_bits_bb_0, '0', lora2_lora_whiten_0, '0']
- [blocks_socket_pdu_0_0, pdus, blocks_pdu_set_0, pdus]
- [blocks_tag_gate_0, '0', osmosdr_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', lora2_lora_add_preamble_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, digital_protocol_formatter_async_0, in]
- [digital_protocol_formatter_async_0, header, virtual_sink_0_1, '0']
- [digital_protocol_formatter_async_0, payload, virtual_sink_0_1_0, '0']
- [fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_tag_gate_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [lora2_css_mod_0, '0', lora2_lora_add_reversed_chirps_0, '0']
- [lora2_flip_half_bytes_0, '0', blocks_repack_bits_bb_0, '0']
- [lora2_gray_decode_0, '0', lora2_lora_low_rate_opt_tx_0, '0']
- [lora2_gray_decode_0_0, '0', virtual_sink_1_0, '0']
- [lora2_lora_add_preamble_0, '0', lora2_css_mod_0, '0']
- [lora2_lora_add_reversed_chirps_0, '0', virtual_sink_1_0_0, '0']
- [lora2_lora_crc_0, pdus, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [lora2_lora_drop_rem_0, '0', lora2_lora_hamming_encode_0_0, '0']
- [lora2_lora_hamming_encode_0, '0', lora2_lora_interleaver_0, '0']
- [lora2_lora_hamming_encode_0_0, '0', lora2_lora_pad_0, '0']
- [lora2_lora_interleaver_0, '0', lora2_gray_decode_0, '0']
- [lora2_lora_interleaver_1, '0', lora2_gray_decode_0_0, '0']
- [lora2_lora_low_rate_opt_tx_0, '0', virtual_sink_1, '0']
- [lora2_lora_pad_0, '0', lora2_lora_interleaver_1, '0']
- [lora2_lora_whiten_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [low_pass_filter_1, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', blocks_pdu_to_tagged_stream_0_0_0_0, pdus]
- [virtual_source_0_0, '0', blocks_pdu_to_tagged_stream_0_0_0_0_0, pdus]
- [virtual_source_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_0_0_0_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_0_0_0_0, '0', low_pass_filter_1, '0']
- [virtual_source_0_1, '0', blocks_tagged_stream_mux_0, '0']

metadata:
  file_format: 1
