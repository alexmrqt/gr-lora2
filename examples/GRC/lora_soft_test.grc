options:
  parameters:
    generate_options: qt_gui
    id: lora_soft_test
    output_language: python
    title: LoRa Soft Test
  states: {}

blocks:
- name: CR
  id: variable
  parameters:
    value: '4'
  states: {}
- name: M
  id: variable
  parameters:
    value: 2**SF
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: hdr_format
  id: lora2_lora_header_format
  parameters:
    SF: SF
  states: {}
- name: hdr_format_0
  id: lora2_lora_header_format
  parameters:
    SF: SF
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1.0/3.14
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: M
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("has_crc")
    v: pmt.PMT_T if has_crc else pmt.PMT_F
  states: {}
- name: blocks_pdu_set_0_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("CR")
    v: pmt.from_long(CR)
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len_bits
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: short
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len_bits
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: SF
    type: float
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '8'
    header_padding: '0'
    items_per_symbol: SF
    length_tag_key: '"packet_len_syms"'
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: ()
    timing_tag_key: ''
    trigger_tag_key: '"pkt_start"'
    type: float
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '2'
    taps: '[1.0]'
    type: ccc
  states: {}
- name: lora2_css_demod_0
  id: lora2_css_demod
  parameters:
    B_cfo: '0.3'
    B_delay: '0.3'
    M: M
    interp: '4'
  states: {}
- name: lora2_css_llr_converter_0
  id: lora2_css_llr_converter
  parameters:
    M: M
    SF: SF
    sigma_b: '1.0'
    true_llr: 'False'
  states: {}
- name: lora2_css_mod_0
  id: lora2_css_mod
  parameters:
    M: M
    interp: '2'
  states: {}
- name: lora2_flip_half_bytes_0
  id: lora2_flip_half_bytes
  parameters: {}
  states: {}
- name: lora2_flip_half_bytes_0_0
  id: lora2_flip_half_bytes
  parameters: {}
  states: {}
- name: lora2_gray_decode_0
  id: lora2_gray_decode
  parameters: {}
  states: {}
- name: lora2_gray_decode_0_0
  id: lora2_gray_decode
  parameters: {}
  states: {}
- name: lora2_lora_add_preamble_0
  id: lora2_lora_add_preamble
  parameters:
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload_start"'
    pre_len: '8'
    sync_word: '0x12'
    sync_word_tag_key: '"sync_word"'
  states: {}
- name: lora2_lora_add_reversed_chirps_0
  id: lora2_lora_add_reversed_chirps
  parameters:
    SF: SF
    interp: '2'
    len_tag_key: '"packet_len"'
    payload_tag_key: '"payload_start"'
    rev_chirps_tag_key: '"rev_chirp"'
  states: {}
- name: lora2_lora_crc_0
  id: lora2_lora_crc
  parameters:
    check: 'False'
  states: {}
- name: lora2_lora_crc_0_0
  id: lora2_lora_crc
  parameters:
    check: 'True'
  states: {}
- name: lora2_lora_drop_rem_0
  id: lora2_lora_drop_rem
  parameters:
    SF: SF
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_hamming_encode_0
  id: lora2_lora_hamming_encode
  parameters:
    CR: '4'
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_hamming_encode_0_0
  id: lora2_lora_hamming_encode
  parameters:
    CR: CR
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_interleaver_0
  id: lora2_lora_interleaver
  parameters:
    CR: '4'
    SF: SF
    len_tag_key: packet_len
    reduced_rate: 'True'
  states: {}
- name: lora2_lora_interleaver_1
  id: lora2_lora_interleaver
  parameters:
    CR: CR
    SF: SF
    len_tag_key: packet_len
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_low_rate_opt_tx_0
  id: lora2_lora_low_rate_opt_tx
  parameters: {}
  states: {}
- name: lora2_lora_merge_rem_0
  id: lora2_lora_merge_rem
  parameters:
    SF: SF
    len_tag_key: packet_len_bits
  states: {}
- name: lora2_lora_pad_0
  id: lora2_lora_pad
  parameters:
    CR: CR
    SF: SF
    len_tag_key: '"packet_len"'
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_preamble_detect_0_0
  id: lora2_lora_preamble_detect
  parameters:
    SF: SF
    preamble_len: '8'
    thres: '1e-6'
  states: {}
- name: lora2_lora_soft_deinterleaver_0
  id: lora2_lora_soft_deinterleaver
  parameters:
    CR: '4'
    SF: SF
    reduced_rate: 'True'
  states: {}
- name: lora2_lora_soft_deinterleaver_0_0
  id: lora2_lora_soft_deinterleaver
  parameters:
    CR: '0'
    SF: SF
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_soft_depad_0
  id: lora2_lora_soft_depad
  parameters:
    len_tag_key: packet_len_bits
    n_pad: '0'
  states: {}
- name: lora2_lora_soft_hamming_decode_0
  id: lora2_lora_soft_hamming_decode
  parameters:
    CR: '4'
    len_tag_key: ''
  states: {}
- name: lora2_lora_soft_hamming_decode_0_0
  id: lora2_lora_soft_hamming_decode
  parameters:
    CR: '0'
    len_tag_key: packet_len_bits
  states: {}
- name: lora2_lora_soft_low_rate_opt_rx_0
  id: lora2_lora_soft_low_rate_opt_rx
  parameters:
    SF: SF
  states: {}
- name: lora2_lora_whiten_0
  id: lora2_lora_whiten
  parameters:
    len_tag_key: packet_len
  states: {}
- name: lora2_lora_whiten_0_0
  id: lora2_lora_whiten
  parameters:
    len_tag_key: packet_len_bits
  states: {}
- name: lora2_soft_gray_encode_0
  id: lora2_soft_gray_encode
  parameters:
    bpw: SF-2
  states: {}
- name: lora2_soft_gray_encode_0_0
  id: lora2_soft_gray_encode
  parameters:
    bpw: SF
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: ''
    size: M*20*2
    srate: '1.0'
    tr_tag: '0'
    type: float
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: header_syms
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: payload_syms
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: signal_decim
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: to_hdr_demod
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: hdr_data
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: demod_syms
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: to_payload_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: payload_syms
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: header_syms
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: signal_decim
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: to_hdr_demod
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: hdr_data
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: demod_syms
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: to_payload_demod
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_complex_to_mag_0_0, '0', lora2_css_llr_converter_0, '0']
- [blocks_pdu_set_0, pdus, blocks_pdu_set_0_0, pdus]
- [blocks_pdu_set_0_0, pdus, lora2_lora_crc_0, pdus]
- [blocks_pdu_to_tagged_stream_0_0_0, '0', lora2_flip_half_bytes_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0_0, '0', lora2_lora_hamming_encode_0, '0']
- [blocks_pdu_to_tagged_stream_0_0_0_0_0, '0', lora2_lora_drop_rem_0, '0']
- [blocks_repack_bits_bb_0, '0', lora2_lora_whiten_0, '0']
- [blocks_repack_bits_bb_0_0, '0', lora2_flip_half_bytes_0_0, '0']
- [blocks_socket_pdu_0_0, pdus, blocks_pdu_set_0, pdus]
- [blocks_tag_gate_0, '0', fir_filter_xxx_0, '0']
- [blocks_tagged_stream_mux_0, '0', lora2_lora_add_preamble_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, digital_protocol_formatter_async_0, in]
- [blocks_tagged_stream_to_pdu_0_0, pdus, lora2_lora_crc_0_0, pdus]
- [blocks_vector_to_stream_1, '0', digital_header_payload_demux_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_1_1, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_4, '0']
- [digital_protocol_formatter_async_0, header, virtual_sink_0_1, '0']
- [digital_protocol_formatter_async_0, payload, virtual_sink_0_1_0, '0']
- [digital_protocol_parser_b_0, info, virtual_sink_2, '0']
- [fir_filter_xxx_0, '0', virtual_sink_1_0_0_0, '0']
- [lora2_css_demod_0, '0', blocks_null_sink_0_0_1, '0']
- [lora2_css_demod_0, '1', blocks_complex_to_mag_0_0, '0']
- [lora2_css_demod_0, '2', blocks_null_sink_0_0, '0']
- [lora2_css_demod_0, '3', blocks_null_sink_0_0_0, '0']
- [lora2_css_llr_converter_0, '0', virtual_sink_3, '0']
- [lora2_css_mod_0, '0', lora2_lora_add_reversed_chirps_0, '0']
- [lora2_flip_half_bytes_0, '0', blocks_repack_bits_bb_0, '0']
- [lora2_flip_half_bytes_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [lora2_gray_decode_0, '0', lora2_lora_low_rate_opt_tx_0, '0']
- [lora2_gray_decode_0_0, '0', virtual_sink_1_0, '0']
- [lora2_lora_add_preamble_0, '0', lora2_css_mod_0, '0']
- [lora2_lora_add_reversed_chirps_0, '0', virtual_sink_1_0_0, '0']
- [lora2_lora_crc_0, pdus, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [lora2_lora_crc_0_0, pdus, blocks_message_debug_0, print_pdu]
- [lora2_lora_crc_0_0, pdus, blocks_socket_pdu_0, pdus]
- [lora2_lora_drop_rem_0, '0', lora2_lora_hamming_encode_0_0, '0']
- [lora2_lora_hamming_encode_0, '0', lora2_lora_interleaver_0, '0']
- [lora2_lora_hamming_encode_0_0, '0', lora2_lora_pad_0, '0']
- [lora2_lora_interleaver_0, '0', lora2_gray_decode_0, '0']
- [lora2_lora_interleaver_1, '0', lora2_gray_decode_0_0, '0']
- [lora2_lora_low_rate_opt_tx_0, '0', virtual_sink_1, '0']
- [lora2_lora_merge_rem_0, '0', lora2_lora_whiten_0_0, '0']
- [lora2_lora_pad_0, '0', lora2_lora_interleaver_1, '0']
- [lora2_lora_preamble_detect_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [lora2_lora_preamble_detect_0_0, '0', lora2_css_demod_0, '0']
- [lora2_lora_soft_deinterleaver_0, '0', lora2_lora_soft_hamming_decode_0, '0']
- [lora2_lora_soft_deinterleaver_0_0, '0', lora2_lora_soft_depad_0, '0']
- [lora2_lora_soft_depad_0, '0', lora2_lora_soft_hamming_decode_0_0, '0']
- [lora2_lora_soft_hamming_decode_0, '0', digital_protocol_parser_b_0, '0']
- [lora2_lora_soft_hamming_decode_0_0, '0', lora2_lora_merge_rem_0, '0']
- [lora2_lora_soft_low_rate_opt_rx_0, '0', lora2_soft_gray_encode_0, '0']
- [lora2_lora_whiten_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [lora2_lora_whiten_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [lora2_soft_gray_encode_0, '0', lora2_lora_soft_deinterleaver_0, '0']
- [lora2_soft_gray_encode_0_0, '0', lora2_lora_soft_deinterleaver_0_0, '0']
- [virtual_source_0, '0', blocks_pdu_to_tagged_stream_0_0_0_0, pdus]
- [virtual_source_0_0, '0', blocks_pdu_to_tagged_stream_0_0_0_0_0, pdus]
- [virtual_source_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_0_0_0_0, '0', blocks_tag_gate_0, '0']
- [virtual_source_0_1, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0_2, '0', lora2_lora_preamble_detect_0_0, '0']
- [virtual_source_1, '0', lora2_lora_soft_low_rate_opt_rx_0, '0']
- [virtual_source_2, '0', digital_header_payload_demux_0, header_data]
- [virtual_source_3, '0', blocks_vector_to_stream_1, '0']
- [virtual_source_4, '0', lora2_soft_gray_encode_0_0, '0']

metadata:
  file_format: 1
