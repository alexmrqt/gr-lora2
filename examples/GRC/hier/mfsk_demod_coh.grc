options:
  parameters:
    author: Alexandre Marquet
    category: lora2
    generate_options: hb
    id: grc_mfsk_demod_coh
    output_language: python
    title: GRC M-FSK Coherent Demodulator
  states: {}

blocks:
- name: M
  id: parameter
  parameters:
    label: M
    value: '128'
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: M
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: M
  states: {}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    tagname: phase
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: M
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: M
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: M
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: M
    forward: 'True'
    shift: 'True'
    type: complex
    window: numpy.ones(M)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: note_0
  id: note
  parameters:
    note: Hope newer versions of GR fix vector operations for this block.
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: short
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: const
    optional: 'True'
    type: complex
    vlen: M
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [blocks_argmax_xx_0, '0', pad_sink_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_real_0, '0', blocks_argmax_xx_0, '0']
- [blocks_multiply_by_tag_value_cc_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_complex_to_real_0, '0']
- [blocks_stream_to_vector_1, '0', pad_sink_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
