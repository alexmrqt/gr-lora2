<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>grc_lora_add_preamble</value></param>
<param><key>author</key><value>Alexandre Marquet</value></param>
<param><key>category</key><value>lora2</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>GRC LoRa Add Preamble</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>pre_end_tag</value></param>
<param><key>key</key><value>pmt.intern(pre_end_tag_key)</value></param>
<param><key>offset</key><value>len(preamble_sync)-1</value></param>
<param><key>src</key><value>pmt.intern("src")</value></param>
<param><key>value</key><value>pmt.PMT_NIL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_sync</value></param>
<param><key>value</key><value>numpy.concatenate((numpy.zeros(preamble_len), [sync_word, sync_word]))</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>len_tag_key</value></param>
<param><key>packet_len</key><value>len(preamble_sync)</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>lengthtagname</key><value>len_tag_key</value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[pre_end_tag]</value></param>
<param><key>vector</key><value>numpy.array(preamble_sync, dtype=numpy.int16).tolist()</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>len_tag_key</value></param>
<param><key>label</key><value>Length Tag Key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_end_tag_key</value></param>
<param><key>label</key><value>Preamble End Tag Key</value></param>
<param><key>value</key><value>"pre_end"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble length [6-65535]</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>label</key><value>Sync word</value></param>
<param><key>value</key><value>0x12</value></param>
</block>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
