options:
  parameters:
    generate_options: qt_gui
    id: lora_rx
    output_language: python
    title: LoRa RX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2**SF
  states: {}
- name: RF_samp_rate
  id: variable
  parameters:
    value: '1800000'
  states: {}
- name: SF
  id: variable
  parameters:
    value: '9'
  states: {}
- name: chan_bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: chan_freq
  id: variable
  parameters:
    value: 868e6
  states: {}
- name: chan_margin
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: int(RF_samp_rate//(interp*chan_bw))
  states: {}
- name: frac_decim
  id: variable
  parameters:
    value: RF_samp_rate/((RF_samp_rate//(interp*chan_bw))*(interp*chan_bw))
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: RF_samp_rate//2
  states: {}
- name: hdr_format
  id: lora2_lora_header_format
  parameters:
    SF: SF
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '10.7'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1.0/numpy.pi
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: M
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: M
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len_bits
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len_bits
    type: byte
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '8'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"packet_len_syms"'
    output_symbols: 'False'
    samp_rate: '1.0'
    special_tags: ()
    timing_tag_key: ''
    trigger_tag_key: '"pkt_start"'
    type: short
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-freq_offset'
    decim: '1'
    samp_rate: RF_samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: lora2_css_demod_0
  id: lora2_css_demod
  parameters:
    B_cfo: '0.3'
    B_delay: '0.3'
    M: M
    interp: '4'
  states: {}
- name: lora2_flip_half_bytes_0
  id: lora2_flip_half_bytes
  parameters: {}
  states: {}
- name: lora2_gray_encode_0
  id: lora2_gray_encode
  parameters: {}
  states: {}
- name: lora2_gray_encode_0_0
  id: lora2_gray_encode
  parameters: {}
  states: {}
- name: lora2_lora_crc_0
  id: lora2_lora_crc
  parameters:
    check: 'True'
  states: {}
- name: lora2_lora_deinterleaver_0
  id: lora2_lora_deinterleaver
  parameters:
    CR: '4'
    SF: SF
    reduced_rate: 'True'
  states: {}
- name: lora2_lora_deinterleaver_0_0
  id: lora2_lora_deinterleaver
  parameters:
    CR: '0'
    SF: SF
    reduced_rate: 'False'
  states: {}
- name: lora2_lora_depad_0
  id: lora2_lora_depad
  parameters:
    len_tag_key: packet_len_bits
    n_pad: '0'
  states: {}
- name: lora2_lora_hamming_decode_0
  id: lora2_lora_hamming_decode
  parameters:
    CR: '4'
    len_tag_key: ''
  states: {}
- name: lora2_lora_hamming_decode_0_0
  id: lora2_lora_hamming_decode
  parameters:
    CR: '0'
    len_tag_key: packet_len_bits
  states: {}
- name: lora2_lora_low_rate_opt_rx_0
  id: lora2_lora_low_rate_opt_rx
  parameters: {}
  states: {}
- name: lora2_lora_merge_rem_0
  id: lora2_lora_merge_rem
  parameters:
    SF: SF
    len_tag_key: packet_len_bits
  states: {}
- name: lora2_lora_preamble_detect_0_0
  id: lora2_lora_preamble_detect
  parameters:
    SF: SF
    preamble_len: '8'
    thres: '1e-4'
  states: {}
- name: lora2_lora_whiten_0
  id: lora2_lora_whiten
  parameters:
    len_tag_key: packet_len_bits
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (chan_bw + chan_margin)/2
    decim: decim
    gain: '1'
    samp_rate: RF_samp_rate
    type: fir_filter_ccf
    width: (chan_bw + chan_margin)/8
    win: firdes.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0.0'
    resamp_ratio: frac_decim
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '0'
    corr0: ppm
    dc_offset_mode0: '2'
    freq0: chan_freq+freq_offset
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: RF_samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: RF_samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: ''
    marker1: '8'
    name: '"CFO Error"'
    size: '400'
    srate: '1.0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"pkt_start"'
    type: float
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: ''
    marker1: '8'
    name: '"Delay Error"'
    size: '400'
    srate: '1.0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"pkt_start"'
    type: float
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: ''
    name: ''
    size: 100*M
    srate: '1.0'
    tr_delay: 20*M
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"time_offset"'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered_sig
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: to_hdr_demod
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: hdr_data
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: demod_syms
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: to_payload_demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered_sig
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: to_hdr_demod
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: hdr_data
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: demod_syms
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: to_payload_demod
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', lora2_flip_half_bytes_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, lora2_lora_crc_0, pdus]
- [digital_header_payload_demux_0, '0', virtual_sink_1, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_4, '0']
- [digital_protocol_parser_b_0, info, virtual_sink_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [lora2_css_demod_0, '0', virtual_sink_3, '0']
- [lora2_css_demod_0, '1', blocks_null_sink_0, '0']
- [lora2_css_demod_0, '2', blocks_multiply_const_vxx_0, '0']
- [lora2_css_demod_0, '3', qtgui_time_sink_x_0_0_0_0, '0']
- [lora2_flip_half_bytes_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [lora2_gray_encode_0, '0', lora2_lora_deinterleaver_0, '0']
- [lora2_gray_encode_0_0, '0', lora2_lora_deinterleaver_0_0, '0']
- [lora2_lora_crc_0, pdus, blocks_message_debug_0, print_pdu]
- [lora2_lora_crc_0, pdus, blocks_socket_pdu_0, pdus]
- [lora2_lora_deinterleaver_0, '0', lora2_lora_hamming_decode_0, '0']
- [lora2_lora_deinterleaver_0_0, '0', lora2_lora_depad_0, '0']
- [lora2_lora_depad_0, '0', lora2_lora_hamming_decode_0_0, '0']
- [lora2_lora_hamming_decode_0, '0', digital_protocol_parser_b_0, '0']
- [lora2_lora_hamming_decode_0_0, '0', lora2_lora_merge_rem_0, '0']
- [lora2_lora_low_rate_opt_rx_0, '0', lora2_gray_encode_0, '0']
- [lora2_lora_merge_rem_0, '0', lora2_lora_whiten_0, '0']
- [lora2_lora_preamble_detect_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [lora2_lora_preamble_detect_0_0, '0', lora2_css_demod_0, '0']
- [lora2_lora_whiten_0, '0', blocks_repack_bits_bb_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [virtual_source_0, '0', lora2_lora_preamble_detect_0_0, '0']
- [virtual_source_1, '0', lora2_lora_low_rate_opt_rx_0, '0']
- [virtual_source_2, '0', digital_header_payload_demux_0, header_data]
- [virtual_source_3, '0', digital_header_payload_demux_0, '0']
- [virtual_source_4, '0', lora2_gray_encode_0_0, '0']

metadata:
  file_format: 1
